# IAR project battery.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051x8 ST STM32F051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F051; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: FWlib\inc; CMSIS; USER\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: battery.hex
  ILINK.IlinkOutputFile: battery.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    CMSIS/: core_cm0.h core_cmFunc.h core_cmInstr.h system_stm32f0xx.c
    CMSIS/startup/: cstartup_M.s vector_table_M.s
  group FWlib
    FWlib/inc/: flash_config.h stm32f0xx.h stm32f0xx_adc.h stm32f0xx_exti.h stm32f0xx_flash.h stm32f0xx_gpio.h stm32f0xx_misc.h stm32f0xx_rcc.h stm32f0xx_syscfg.h stm32f0xx_tim.h system_stm32f0xx.h
    FWlib/src/: stm32f0xx_adc.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c
  group USER
    USER/src/: battery_led.c battery_power.c battery_stat.c battery_supply.c battery_tablet.c button.c charge_pal_sys.c main.c stm32_adc.c stm32_led.c stm32_timer.c stm32f0xx_it.c
    USER/inc/: battery_led.h battery_power.h battery_stat.h battery_supply.h battery_tablet.h button.h charge_pal_sys.h stm32_adc.h stm32_led.h stm32_timer.h stm32f0xx_conf.h stm32f0xx_it.h sys_common.h sys_pin_def.h
